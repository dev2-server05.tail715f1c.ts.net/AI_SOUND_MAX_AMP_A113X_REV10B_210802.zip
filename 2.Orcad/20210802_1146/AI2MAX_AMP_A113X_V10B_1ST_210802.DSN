# OrCAD Capture schematic AI2MAX_AMP_A113X_V10B_1ST_210802.DSN, sheets 10 to 11 of 11

## Sheets
10 10: AUDIO AMP LEFT: size A3; title: 10. AUDIO AMP_LEFT
11 09: A113X_PERIPHERAL: size A3; title: 09. A113X_PERIPHERAL

## Parts
sheet 05: A113X_IO
U1  A113X  [A113x]  (sections A,B,C,D,E,F,G)
sheet 09: A113X_PERIPHERAL
C101  104P/16V/1005  [C0402]
C102  105P/6.3V/1005  [C0402]
C103  OPEN-150P/50V/1005  [c1005]
C104  OPEN-150P/50V/1005  [c1005]
C105  OPEN-150P/50V/1005  [c1005]
C106  OPEN-150P/50V/1005  [c1005]
R101  OPEN-000/1005  [r1005]
R102  OPEN-330/1005  [r1005]
R103  101/1005  [r1005]
R104  101/1005  [r1005]
R105  000/1005  [r1005]
R106  OPEN-000/1005  [r1005]
R107  101/1005  [r1005]
R108  101/1005  [r1005]
R109  BLM15PD121SN1D  [BLM15]
R110  BLM15PD121SN1D  [BLM15]
R343  101/1005  [r1005]
R344  101/1005  [r1005]
T101  T_POINT_R_1  [tp0_8pi]
T102  T_POINT_R_1  [tp0_8pi]
T103  T_POINT_R_1  [tp0_8pi]
T104  T_POINT_R_1  [tp0_8pi]
T105  T_POINT_R_1  [tp0_8pi]
T106  T_POINT_R_1  [tp0_8pi]
T107  T_POINT_R_1  [tp0_8pi]
T108  T_POINT_R_1  [tp0_8pi]
T109  T_POINT_R_1  [tp0_8pi]
T110  T_POINT_R_1  [tp0_8pi]
T111  T_POINT_R_1  [tp0_8pi]
T112  T_POINT_R_1  [tp0_8pi]
T113  T_POINT_R_1  [tp0_8pi]
T114  T_POINT_R_1  [tp0_8pi]
T115  T_POINT_R_1  [tp0_8pi]
T116  T_POINT_R_1  [tp0_8pi]
T120  T_POINT_R_1  [tp0_8pi]
T125  T_POINT_R_1  [tp0_8pi]
T126  T_POINT_R_1  [tp0_8pi]
T127  T_POINT_R_1  [tp0_8pi]
T129  T_POINT_R_1  [TP1_0PI]
T319  T_POINT_R_1  [TP1_0PI]
T320  T_POINT_R_1  [TP1_0PI]
T321  T_POINT_R_1  [TP1_0PI]
T322  T_POINT_R_1  [TP1_0PI]
T323  T_POINT_R_1  [TP1_0PI]
T324  T_POINT_R_1  [TP1_0PI]
T325  T_POINT_R_1  [TP1_0PI]
T326  T_POINT_R_1  [TP1_0PI]
T327  T_POINT_R_1  [TP1_0PI]
T328  T_POINT_R_1  [TP1_0PI]
T329  T_POINT_R_1  [TP1_0PI]
T330  T_POINT_R_1  [TP1_0PI]
T331  T_POINT_R_1  [TP1_0PI]
sheet 10: AUDIO AMP LEFT
C201  105P/6.3V/1608  [c1608]
C202  223P/16V/1005  [c1005]
C203  271P/50V/1608  [c1608]
C204  104P/16V/1005  [c1005]
C205  100uF/35V/CLZ  [ecap_8pi_h10]
C206  104P/50V/1608  [c1608]
C207  271P/50V/1608  [c1608]
C208  OPEN-104P/16V/1005  [c1005]
C209  105P/50V/1608  [c1608]
C210  223P/16V/1005  [c1005]
C211  105P/16V/1608  [c1608]
C213  471P/50V/1608  [c1608]
C214  105P/16V/1608  [c1608]
C215  223P/16V/1005  [c1005]
C216  105P/50V/1608  [c1608]
C217  330P/50V/1005  [c1005]
C218  105P/6.3V/1608  [c1608]
C219  271P/50V/1608  [c1608]
C220  223P/16V/1005  [c1005]
C221  271P/50V/1608  [c1608]
C222  330P/50V/1005  [c1005]
C223  100uF/35V/CLZ  [ecap_8pi_h10]
C224  104P/50V/1608  [c1608]
C225  223P/16V/1005  [c1005]
C226  104P/16V/1005  [c1005]
C228  271P/50V/1608  [c1608]
C229  271P/50V/1608  [c1608]
C230  105P/6.3V/1608  [c1608]
C231  104P/50V/1608  [c1608]
C232  OPEN-104P/16V/1005  [c1005]
C233  105P/50V/1608  [c1608]
C234  223P/16V/1005  [c1005]
C235  105P/16V/1608  [c1608]
C237  471P/50V/1608  [c1608]
C238  105P/16V/1608  [c1608]
C239  223P/16V/1005  [c1005]
C240  105P/50V/1608  [c1608]
C241  330P/50V/1005  [c1005]
C242  105P/6.3V/1608  [c1608]
C243  271P/50V/1608  [c1608]
C244  223P/16V/1005  [c1005]
C245  271P/50V/1608  [c1608]
C246  330P/50V/1005  [c1005]
C248  104P/50V/1608  [c1608]
C249  OPEN-105P/6.3V/1608  [c1608]
C250  OPEN-104P/16V/1005  [c1005]
C251  OPEN-330P/50V/1005  [c1005]
C252  OPEN-330P/50V/1005  [c1005]
C253  OPEN-330P/50V/1005  [c1005]
C254  OPEN-330P/50V/1005  [c1005]
C255  106P/35V/3216  [C3216]
C256  106P/35V/3216  [C3216]
C257  106P/35V/3216  [C3216]
C258  106P/35V/3216  [C3216]
C259  121\P/50V/1608  [c1608]
C260  121\P/50V/1608  [c1608]
C261  121\P/50V/1608  [c1608]
C262  121\P/50V/1608  [c1608]
C263  OPEN-224P/50V/1608  [c1608]
C264  OPEN-224P/50V/1608  [c1608]
C265  OPEN-224P/50V/1608  [c1608]
C266  OPEN-224P/50V/1608  [c1608]
C267  OPEN-224P/50V/1608  [c1608]
C268  OPEN-224P/50V/1608  [c1608]
C269  OPEN-224P/50V/1608  [c1608]
C270  OPEN-224P/50V/1608  [c1608]
FB201  CIS21J121NE  [CIS2012]
FB202  120ohm/5A/2012  [BLM21]
FB203  120ohm/5A/2012  [BLM21]
FB204  120ohm/5A/2012  [BLM21]
J803  S4B-EH(LF)(SN)  [SXB-EH-4P]
L201  SPH10040-100M  [COIL_SPH10040]
L202  SPH10040-100M  [COIL_SPH10040]
L203  SPH10040-100M  [COIL_SPH10040]
L204  SPH10040-100M  [COIL_SPH10040]
L211  OPEN-SWPA8065S100NT  [SWPA8065S]
L212  OPEN-SWPA8065S100NT  [SWPA8065S]
L213  OPEN-SWPA8065S100NT  [SWPA8065S]
L214  OPEN-SWPA8065S100NT  [SWPA8065S]
R201  472/1005  [r1005]
R202  6R8/F/2012  [r2012]
R203  6R8/F/2012  [r2012]
R204  472/F/1608  [r1608]
R205  472/F/1608  [r1608]
R206  6R8/F/2012  [r2012]
R207  472/1005  [r1005]
R208  6R8/F/2012  [r2012]
R209  000/1005  [r1005]
R210  000/1005  [r1005]
R211  OPEN-101/1005  [r1005]
R212  OPEN-101/1005  [r1005]
R213  6R8/F/2012  [r2012]
R214  472/1005  [r1005]
R215  101/1005  [r1005]
R216  OPEN-101/1005  [r1005]
R217  6R8/F/2012  [r2012]
R219  OPEN-101/1005  [r1005]
R220  472/F/1608  [r1608]
R221  472/F/1608  [r1608]
R222  6R8/F/2012  [r2012]
R223  472/1005  [r1005]
R224  6R8/F/2012  [r2012]
R225  OPEN-101/1005  [r1005]
R226  OPEN-101/1005  [r1005]
R227  101/1005  [r1005]
R228  101/1005  [r1005]
R229  101/1005  [r1005]
R230  101/1005  [r1005]
R231  OPEN-330/1005  [r1005]
R233  OPEN-100/F/1608  [r1608]
R234  OPEN-100/F/1608  [r1608]
R235  OPEN-100/F/1608  [r1608]
R236  OPEN-100/F/1608  [r1608]
R238  101/1005  [r1005]
R239  101/1005  [r1005]
R240  OPEN-101/1005  [r1005]
R348  102/1005  [r1005]
R349  102/1005  [r1005]
T201  T_POINT_R_1  [tp0_8pi]
T202  T_POINT_R_1  [tp0_8pi]
T203  T_POINT_R_1  [tp0_8pi]
T204  T_POINT_R_1  [tp0_8pi]
T305  T_POINT_R_1  [tp1_0pi]
T306  T_POINT_R_1  [tp1_0pi]
T307  T_POINT_R_1  [tp1_0pi]
T308  T_POINT_R_1  [tp1_0pi]
T309  T_POINT_R_1  [tp1_0pi]
T310  T_POINT_R_1  [tp1_0pi]
T311  T_POINT_R_1  [tp1_0pi]
T312  T_POINT_R_1  [tp1_0pi]
T313  T_POINT_R_1  [tp1_0pi]
T314  T_POINT_R_1  [tp1_0pi]
T315  T_POINT_R_1  [tp1_0pi]
T316  T_POINT_R_1  [tp1_0pi]
T317  T_POINT_R_1  [tp1_0pi]
T318  T_POINT_R_1  [tp1_0pi]
U201  WA20-6829B  [QFN40_p0_5_w6_WA20-6829B]
U202  WA20-6829B  [QFN40_p0_5_w6_WA20-6829B]

## Library data of the parts
U1 = A113X_20170516_V17: Manufacturer: AMLOGIC; Manufacturer Part Number: A113X-B; Part Type: IC AUDIO DSP; Color: Default; Location X-Coordinate: 0; Location Y-Coordinate: 0; Power Pins Visible: False; Primitive: DEFAULT; OriginalSymbolOrigin: LFBGA 284
C101-C106 C202 C204 C208 C210 C215 C217 C220 C222 C225 C226 C232 C234 C239 C241 C244 C246 C250-C254 = MLCC_1005_0: Part Type: MLCC
R101-R110 R201-R217 R219-R231 R233-R236 R238-R240 R343 R344 R348 R349 = RES-V: Part Type: RES SMD
T101-T116 T120 T125-T127 T129 T201-T204 T305-T331 = T_POINT_R_1: Part Type: TP
C201 C203 C206 C207 C209 C211 C213 C214 C216 C218 C219 C221 C224 C228-C231 C233 C235 C237 C238 C240 C242 C243 C245 C248 C249 C255-C270 = MLCC_1608_0: Part Type: MLCC
C205 C223 = ECAP-2.5X6.3-D: Manufacturer: SAMYOUNG; Manufacturer Part Number: CLZ35VC101MH10TP; Part Type: ECAP SMD
FB201 = BEAD: BEAD C 120ohm 25% 3A 0.03ohm SMD 0603 GP/HF; COMPONENT_TYPE: SMD; CURRENTMAX_D4: 3A; FORM_TYPE: STD; GP: CN-GP; ITEM_REV: 3; LIFE_CYCLE: ²{¦æª©¥»; MANUFACTURER: SEM; MEASURE_UNIT: EA; STATUS: ^^^^^^^^; TOLERANCE_D47: 25%
FB202-FB204 = BEAD: BEAD C 120ohm 25% 3A 0.03ohm SMD 0603 GP/HF; COMPONENT_TYPE: SMD; CURRENTMAX_D4: 3A; FORM_TYPE: STD; GP: CN-GP; ITEM_NUMBER: 151.00368.005; ITEM_REV: 3; LIFE_CYCLE: ²{¦æª©¥»; MEASURE_UNIT: EA; NOTES_LINK: http://hcap03.efoxconn.com/app/dc/compmaster.nsf/(vDocNo)/185F50B074F8D5EB48257D2A002B3222?OpenDocument; PART_TYPE: STD\ºÏ©Ê/¥b¾ÉÅé/³Q°Ê¤¸¥ó\FILTER/BEAD\FERRITE BEAD/ FERRITE IND (SMD); STATUS: ^^^^^^^^; STOCK: AAEB:7922,NAEA:28000,NAEZ:848,SH10:13887; TOLERANCE_D47: 25%
J803 = CON4: MANUFACTURER: JST; Part Type: HEADER_1X4_2.5RA
L201-L204 = INDUCTOR_CHIP_0: Manufacturer: LS COMM; OTHER: 1; Part Type: IND POWER
L211-L214 = INDUCTOR_CHIP_0: Manufacturer: SUNLOAD; Manufacturer Part Number: SPH10040-100M; OTHER: 1; Part Type: IND POWER
U201 U202 = WA20-6829B_0: Manufacturer: WELLANG; Part Type: IC CLASS D AMP

## Nets
GND: C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C201.2 C203.1 C204.1 C205.2 C206.2 C207.1 C208.1 C209.2 C211.2 C214.2 C216.1 C217.1 C218.2 C219.1 C221.1 C222.1 C223.2 C224.2 C226.1 C228.1 C229.1 C230.2 C231.2 C232.1 C233.2 C235.2 C238.2 C240.1 C241.1 C242.2 C243.1 C245.1 C246.1 C248.2 C249.2 C250.1 C251.1 C252.1 C253.1 C254.1 C255.2 C256.2 C257.2 C258.2 C259.1 C260.2 C261.1 C262.2 C264.2 C265.1 C268.2 C269.1 R201.2 R204.1 R205.2 R207.1 R220.1 R221.2 R223.1 R233.1 R234.2 R235.1 R236.2 T308.1(TP) T311.1(TP) T312.1(TP) T313.1(TP) T314.1(TP) T315.1(TP) T318.1(TP) T320.1(TP) T321.1(TP) U201.1(NC1) U201.3(NC2) U201.4(GND) U201.5(NC3) U201.9(NC4) U201.17(PGND2B) U201.22(PGND2A) U201.25(AGND) U201.26(NC5) U201.29(PGND1B) U201.34(PGND1A) U201.39(GND_IO) U201.41(E_PAD) U202.1(NC1) U202.3(NC2) U202.4(GND) U202.5(NC3) U202.9(NC4) U202.17(PGND2B) U202.22(PGND2A) U202.25(AGND) U202.26(NC5) U202.29(PGND1B) U202.34(PGND1A) U202.39(GND_IO) U202.41(E_PAD) ; also on sheet 1 2 5 6 7 8 9
VDDAO_3.3V: C101.2 C201.1 C230.1 C249.1 C250.2 R105.1 R214.2 R348.1 R349.1 T129.1(TP) T316.1(TP) T319.1(TP) U1.K14(VDDIO_A) U201.40(VDD_IO) U202.40(VDD_IO) ; also on sheet 1 2 6 9
VDDIO_AO18: R106.1 ; also on sheet 2 5 6 7
VDDIO_X: C102.2 R105.2 R106.2 U1.C8(VDDIO_X)
ACTIVE_STBY: R219.1 U1.B11(GPIOX_19//I2C_SDA_C//UART_CTS_EE_B//SPI_CLK_B//PWM_B) ; also on sheet 9
AMP_RESET: R215.1 T317.1(TP) ; also on sheet 7 9
AMP_SCL: R209.1 ; also on sheet 2 7
AMP_SCL_DEV: R209.2 R238.1 T306.1(TP) ; also on sheet 9
AMP_SDA: R210.1 ; also on sheet 2 7
AMP_SDA_DEV: R210.2 R239.1 T305.1(TP) ; also on sheet 9
CPU_RESET: R240.1 ; also on sheet 2 9
GPIOX_16: T125.1(TP) U1.D10(GPIOX_16//I2C_SCK_B//UART_TX_EE_B//SPI_SS0_B//PWM_D)
GPIOX_17: T126.1(TP) U1.D8(GPIOX_17//I2C_SDA_B//UART_RX_EE_B//SPI_MOSI_B//PWM_C)
GPIOX_18: T127.1(TP) U1.C10(GPIOX_18//I2C_SCK_C//UART_RTS_EE_B//SPI_MISO_B//PWM_A)
I2SIN_BCLK_C: C103.2 R107.2 R227.1 R229.1 R343.2 T309.1(TP) ; also on sheet 7 9
I2SIN_DATA_C: R103.2 R104.2 ; also on sheet 7
I2SIN_LRCK_C: C104.2 R108.2 R228.1 R230.1 R344.2 T307.1(TP) ; also on sheet 7 9
I2SIN_MCLK_B: R102.2 ; also on sheet 7
I2SO_DATA0: C105.2 R109.2 R225.2 R231.2 U201.7(SDATA) ; also on sheet 9
I2SO_DATA1: C106.2 R110.2 R226.2 R231.1 U202.7(SDATA) ; also on sheet 9
I2SO_MCLK_A: R101.2 T101.1(TP)
nPWM_OFF1: R219.2 U201.12(\\~{FAUL}T) U202.12(\\~{FAUL}T)
nRESET_AMP: R216.1 U1.B6(GPIOX_20//PWM_A) ; also on sheet 9
nRST_AMP1: C204.2 C226.2 R215.2 R216.2 R240.2 U201.36(\\~{RESE}T) U202.36(\\~{RESE}T)
OUT1A_B_LF: C233.1 C237.1 C261.2 C267.1 FB203.1 L203.2 L213.2 R220.2
OUT1A_B_LW: C209.1 C213.1 C259.2 C263.1 FB202.2 L201.2 L211.2 R204.2
OUT2A_B_LF: C237.2 C240.2 C262.1 C270.2 FB204.1 L204.2 L214.2 R221.1
OUT2A_B_LW: C213.2 C216.2 C260.1 C266.2 FB201.2 L202.2 L212.2 R205.1
PDM_DCLK: T102.1(TP) U1.E16(GPIOA_14//PDM_DCLK//CLKSYN_IN//PWM_A)
PDM_DIN0: T103.1(TP) U1.E17(GPIOA_15//PDM_DIN0//PWM_B)
PDM_DIN1: T104.1(TP) U1.D16(GPIOA_16//PDM_DIN1//PWM_C)
PDM_DIN2: T105.1(TP) U1.D17(GPIOA_17//PDM_DIN2//I2C_SDA_C//ETH_MDIO)
PDM_DIN3: T106.1(TP) U1.C17(GPIOA_18//PDM_DIN3//I2C_SCK_C//ETH_MDC)
PWR_24V: C205.1 C206.1 C223.1 C224.1 C231.1 C248.1 C255.1 C256.1 C257.1 C258.1 U201.19(PVDD2B) U201.20(PVDD2A) U201.31(PVDD1B) U201.32(PVDD1A) U202.19(PVDD2B) U202.20(PVDD2A) U202.31(PVDD1B) U202.32(PVDD1A) ; also on sheet 1 9
RMII_MDC: T322.1(TP) U1.A11(GPIOX_22//ETH_MDC)
RMII_MDIO: T323.1(TP) U1.A8(GPIOX_21//ETH_MDIO)
RMII_RXCLK: T325.1(TP) U1.B7(GPIOX_12//TDMA_SCLK//TDMA_SLV_SCLK//RMII_RX_CLK)
RMII_RXD0: T327.1(TP) U1.B8(GPIOX_13//TDMA_FS//TDMA_SLV_FS//RMII_RXD0)
RMII_RXD1: T326.1(TP) U1.A6(GPIOX_14//TDMA_DIN0//TDMA_DOUT0//RMII_RXD1)
RMII_RXDV: T324.1(TP) U1.A7(GPIOX_15//TDMA_DOUT0//TDMA_DOUT1//TDMA_DIN1//RMII_RXDV)
RMII_TXD0: T328.1(TP) U1.A10(GPIOX_8//UART_TX_EE_A//RMII_TXD0)
RMII_TXD1: T331.1(TP) U1.C9(GPIOX_9//UART_RX_EE_A//RMII_TXD1)
RMII_TXEN: T329.1(TP) U1.B9(GPIOX_10//UART_CTS_EE_A//PWM_C//RMII_TXEN)
SCL_AMP1: C222.2 C246.2 R211.2 R238.2 R349.2 U201.11(SCL) U202.11(SCL)
SDA_AMP1: C217.2 C241.2 R212.2 R239.2 R348.2 U201.10(SDA) U202.10(SDA)
SPDIF_IN: T107.1(TP) U1.E14(GPIOA_19//SPDIF_IN//SPDIF_OUT//PDM_DCLK//I2C_SDA_D)
SPDIF_OUT: T108.1(TP) U1.C16(GPIOA_20//SPDIF_OUT//SPDIF_IN//CLKSYN_IN//I2C_SCK_D)
SPK_I2C_SCK: R211.1 ; also on sheet 2 9
SPK_I2C_SDA: R212.1 ; also on sheet 2 9
N21476089: R101.1 U1.J16(GPIOA_0//MCLK_C//CLKSYN_IN//PWM_VS)
N21476146: R102.1 U1.H17(GPIOA_1//MCLK_B//SPDIF_IN//SPDIF_OUT//CLKSYN_IN)
N21714583: C202.2 C210.1 L201.1 L211.1 R202.2 R203.1 U201.30(OUT1B) U201.33(OUT1A)
N21714609: C251.2 R227.2 U201.38(BCK)
N21714673: C203.2 R202.1
N21714680: C202.1 U201.35(BST1A)
N21714717: R201.1 U201.37(AD)
N21714779: C207.2 R203.2
N21714803: C208.2 U201.2(VDD_PLL)
N21714950: C210.2 U201.28(BST1B)
N21714966: C211.1 U201.27(VDR1)
N21715014: C218.1 U201.6(DVDD)
N21715038: C214.1 U201.24(VDR2)
N21715056: C215.2 U201.23(BST2A)
N21715058: C215.1 C220.1 L202.1 L212.1 R206.2 R208.1 U201.18(OUT2B) U201.21(OUT2A)
N21715192: C219.2 R206.1
N21715198: T201.1(TP) U201.13(MONITOR_0)
N21715200: R207.2 U201.14(MONITOR_1)
N21715202: T202.1(TP) U201.15(MONITOR_2)
N21715204: C220.2 U201.16(BST2B)
N21715315: C221.2 R208.2
N21715401: FB202.1 J803.1
N21715403: FB201.1 J803.2
N21715405: FB203.2 J803.4
N21715413: FB204.2 J803.3
N21715441: C225.2 C234.1 L203.1 L213.1 R213.2 R217.1 U202.30(OUT1B) U202.33(OUT1A)
N21715461: C253.2 R229.2 U202.38(BCK)
N21715523: C228.2 R213.1
N21715527: C225.1 U202.35(BST1A)
N21715561: R214.1 U202.37(AD)
N21715623: C229.2 R217.2
N21715647: C232.2 U202.2(VDD_PLL)
N21715792: C234.2 U202.28(BST1B)
N21715808: C235.1 U202.27(VDR1)
N21715856: C242.1 U202.6(DVDD)
N21715880: C238.1 U202.24(VDR2)
N21715898: C239.2 U202.23(BST2A)
N21715900: C239.1 C244.1 L204.1 L214.1 R222.2 R224.1 U202.18(OUT2B) U202.21(OUT2A)
N21716032: C243.2 R222.1
N21716038: T203.1(TP) U202.13(MONITOR_0)
N21716040: R223.2 U202.14(MONITOR_1)
N21716042: T204.1(TP) U202.15(MONITOR_2)
N21716044: C244.2 U202.16(BST2B)
N21716155: C245.2 R224.2
N21778072: T109.1(TP) U1.A4(GPIOX_0//SDIO_D0//JTAG_TDO)
N21778081: T110.1(TP) U1.B5(GPIOX_1//SDIO_D1//JTAG_TDI)
N21778090: T111.1(TP) U1.B2(GPIOX_2//SDIO_D2//UART_RX_AO_A)
N21778099: T112.1(TP) U1.A2(GPIOX_3//SDIO_D3//UART_TX_AO_A)
N21778148: T113.1(TP) U1.A3(GPIOX_4//SDIO_CLK//JTAG_CLK)
N21778157: T114.1(TP) U1.B3(GPIOX_5//SDIO_CMD//JTAG_TMS)
N21778166: T115.1(TP) U1.A1(GPIOX_6)
N21778175: T116.1(TP) U1.C3(GPIOX_7)
N21778255: T120.1(TP) U1.B10(GPIOX_11//UART_RTS_EE_A//PWM_D)
N21800110: R225.1 R226.1 T310.1(TP)
N21860313: C252.2 R228.2 U201.8(WCK)
N21864534: C254.2 R230.2 U202.8(WCK)
N21892579: R343.1 U1.G15(GPIOA_8//TDMB_SCLK//TDMB_SLV_SCLK)
N21892587: R344.1 U1.F17(GPIOA_9//TDMB_FS//TDMB_SLV_FS)
N21892603: R103.1 U1.F16(GPIOA_10//TDMB_DOUT0//TDMB_DIN0)
N21892620: R104.1 U1.F15(GPIOA_11//TDMB_DOUT1//TDMB_DIN1//SPDIF_OUT)
N21892674: R107.1 U1.H16(GPIOA_2//TDMC_SCLK//TDMC_SLV_SCLK//SPI_MOSI_B)
N21892682: R108.1 U1.G17(GPIOA_3//TDMC_FS//TDMC_SLV_FS//SPI_MISO_B)
N21892690: R109.1 U1.G16(GPIOA_4//TDMC_DOUT0//TDMC_DIN0//SPI_CLK_B)
N21892698: R110.1 U1.G14(GPIOA_5//TDMC_DOUT1//TDMC_DIN1//SPI_SS0_B)
N22093750: C263.2 C264.1 R233.2
N22093974: C265.2 C266.1 R234.1
N22094186: C267.2 C268.1 R235.2
N22094236: C269.2 C270.1 R236.1

Not connected (* = marked no-connect by the designer): T330 1(TP)*

## Notes on the sheets
sheet 10
- TP -TP: 2.5mm
  Bottom Layer
- OUT1A/OUT1B=(+)
- OUT2A/OUT2B =(-)
- * REV1.0
- LEFT WOOFER
- +
- Device Address: 0x54
- -
- Woofer
- -
- +
- Full Range
- * REV1.0
- OUT1A/OUT1B=(+)
- OUT2A/OUT2B =(-)
- * REV1.0
- LEFT FULL RANGE
- Device Address: 0x56
sheet 11
- * REV1.0
- * DVT3
- 1
- 2
- * DVT3
- 13
- 14
- TP -TP: 2.54mm
  Bottom Layer
